SUMMARY = "Java JDK"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = " \
"
